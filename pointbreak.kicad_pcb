# Repository BeeEvolved/PointBreak

File README.md:

Small.jpg)

# PointBreak
A breakout of the Bitaxe. The PointBreak utilizes a 6-layer PCB design, SP32-S3-WROOM-1U with an external antenna and 42-pin breakout. 
Repo for the orginal [Bitaxe 204](https://github.com/skot/bitaxe/tree/ultra-204)

## KiCad design pointbreak.kicad_pcb

Board: 6 copper layers, 56.7 x 118.6 mm, 137 parts (20 on the bottom side), 61 nets.

Parts:
C1, C7, C9, C19, C20, C29, C33, C42, C52: 0.1uF; C_0402_1005Metric
C2, C3, C4, C5, C6, C8, C10, C11, C12, C14, C15, C16, C17, C18, C21, C22, C23, C24, C25, C27, C35, C44, C49: 1uF; C_0402_1005Metric
C13: 330uF; CP_EIA-7343-31_Kemet-D_Pad2.25x2.55mm_HandSolder
C28: 220uF; CP_Elec_6.3x7.7
C30, C31: 6.8pF; C_0402_1005Metric
C34, C36, C37: 47uF; C_1210_3225Metric
C38: 1uF; C_0805_2012Metric
C39: 3.3nF; C_0402_1005Metric
C40: 180pF; C_0805_2012Metric
C41: 1.5nF; C_0805_2012Metric
C43, C51: 10uF; C_0805_2012Metric
C45: 470pF; C_0805_2012Metric
C46: 220uF; CAP_2R5TPE220MAFB
C47: 100uF; C_1206_3216Metric
D1: SS310; D_SMA
FID1, FID2, FID3, FID4, FID5, FID6, FID7, FID8: Fiducial; Fiducial_1mm_Mask2mm
H5, H6: MountingHole; MountingHole_3.5mm
H7, H8, H9, H10: MountingHole_Pad; MountingHole_3mm_Pad_Via
J1: 54-00164; BarrelJack_Wuerth_694106106102_2.0x5.5mm
J2: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J3#2, J4: Conn_01x21; PinHeader_1x21_P2.54mm_Vertical
J4#2: Conn_01x04; 470531000
J5: TC2030-IDC; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J7: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J8: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J9: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical_SMD_Pin1Right
L1: 150nH; FP1005R1-R15-R
Q1, Q2: CSD17311Q5
Q4: 2N7002K; SOT-323_SC-70
R1, R4, R6, R7, R9: 10k; R_0402_1005Metric
R2: 5.6k; R_0402_1005Metric
R3, R5: 5.1k; R_0402_1005Metric
R8: 1M; R_0402_1005Metric
R10: 3.83k; R_0402_1005Metric
R12: 4.12k; R_0402_1005Metric
R13: 1.33k; R_0402_1005Metric
R14: 4.99k; R_0402_1005Metric
R15: 3.32k; R_0402_1005Metric
R16: 80.6k; R_0402_1005Metric
SW1, SW2: GT-TC029B-H025-L1N; SW_CS1213AGF260_CRS
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP22, TP23, TP34, TP35, TP36, TP38, TP40, TP41, TP42, TP43, TP44, TP45, TP46: TestPoint; TestPoint_Pad_D1.5mm
U1: 25MHz; O 25,0-JO32-B-1V3-1-T1-LF
U2: TXB0104RGYR; TXB0104
U3: polarity
U5: MCP1824T-1802E; SOT-23-5
U6: MCP1824T-0802E; SOT-23-5
U7: EMC2101; TSSOP-8_3x3mm_P0.65mm
U8: INA260; TSSOP-16_4.4x5mm_P0.65mm
U9: TPS40305
U10: DS4432U+; TSSOP-8_3x3mm_P0.65mm
U11: RT9080-33GJ5
U12: ESP32-S3-WROOM-1
U14: BM1366_mode1; BM1366
Y1: 32.768kHz; SC32S-7PF20PPM

Connections:
/3V3: C20.1, C33.1, C35.1, C44.1, C49.1, C51.1, C52.1, J4.2, J4.15, J5.2, J9.2, R1.1, R2.2, R4.1, R7.1, R8.1, R9.2, TP19.1, U2.14 (VCCB), U7.1 (VDD), U8.10 (VS), U10.8 (VCC), U11.5 (VOUT), U12.2 (3V3), U12.15 (GPIO3/TOUCH3/ADC1_CH2*)
/5V: C22.1, C23.1, C27.1, C28.1, C29.1, C34.1, C36.1, C37.1, C38.1, D1.1, J2.2, J3#2.21, J4.21, J4#2.2, J7.2, Q1.5 (D), U5.1 (VIN), U5.3 (EN), U6.1 (VIN), U6.3 (EN), U8.14 (IN-), U8.15 (IN-), U8.16 (IN-), U9.1 (VDD), U11.1 (VIN), U11.3 (EN)
/BM1366/0V8: C4.1, C25.1, TP14.1, U6.5 (VOUT), U14.13 (VDDIO_08_0)
/BM1366/1V8: C1.2, C5.1, C19.1, C24.1, J3.1, TP13.1, U1.1 (EN), U1.4 (VIN), U2.1 (VCCA), U2.8 (OE), U5.5 (VOUT), U14.14 (VDDIO_18_0)
/BM1366/ADDR0: TP8.1, U14.10 (ADDR0)
/BM1366/ADDR1: TP10.1, U14.11 (ADDR1)
/BM1366/BI: R6.2, TP9.1, U14.6 (BI)
/BM1366/BO: TP1.1, U14.23 (BO)
/BM1366/CI: J3.2, TP2.1, U2.3 (A2), U14.9 (CI)
/BM1366/CLKI: TP7.1, U1.3 (OUT), U14.8 (CLKI)
/BM1366/CLKO: TP44.1, U14.21 (CLKO)
/BM1366/CO: TP45.1, U14.20 (CO)
/BM1366/INV_CLKO: TP6.1, U14.19 (INV_CLKO)
/BM1366/NRSTO: TP38.1, U14.24 (NRSTO)
/BM1366/PIN_MODE: TP46.1, U14.18 (PIN_MODE)
/BM1366/RI: TP43.1, U14.22 (RI)
/BM1366/RO: J3.3, TP3.1, U2.2 (A1), U14.7 (RO)
/BM1366/RST_N: J3.4, TP4.1, U2.4 (A3), U14.5 (NRSTI)
/BM1366/VDD1_0: C6.2, C8.1, TP34.1, U14.1 (VDD1_0)
/BM1366/VDD1_1: C12.2, C15.1, TP42.1, U14.28 (VDD1_1)
/BM1366/VDD2_0: C3.2, C6.1, TP35.1, U14.2 (VDD2_0)
/BM1366/VDD2_1: C15.2, C17.1, TP41.1, U14.27 (VDD2_1)
/BM1366/VDD3_0: C2.2, C3.1, TP36.1, U14.3 (VDD3_0)
/BM1366/VDD3_1: C17.2, C18.1, TP40.1, U14.26 (VDD3_1)
/ESP32/EN: C21.1, J4.3, J5.1, R1.2, SW1.2, TP17.1, U12.3 (EN)
/ESP32/IO0: J3#2.14, J5.6, SW2.2, TP23.1, U12.27 (GPIO0/BOOT*)
/ESP32/PWR_EN: J4.18, Q4.1 (G), R7.2, U12.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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)
/ESP32/P_RX: J3#2.5, J5.5, TP22.1, U12.36 (U0RXD/GPIO44/CLK_OUT2)
/ESP32/P_TX: J3#2.4, J5.3, TP18.1, U12.37 (U0TXD/GPIO43/CLK_OUT1)
/ESP32/XIN32: C30.1, J4.8, U12.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P), Y1.1
/ESP32/XOUT32: C31.1, J4.9, U12.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_NH5), Y1.2
/Fan/FAN_PWM: J4#2.4, R9.1, TP15.1, U7.4 (FAN)
/Fan/FAN_TACH: J4#2.3, R2.1, TP16.1, U7.6 (ALERT/TACH)
/PLUG_SENSE: J1.3, J4.20, R8.2, U12.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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)
/Power/OUT0: C40.2, C45.2, R10.2, R14.2, R15.1, U9.5 (FB), U10.6 (OUT0)
/Power/PGOOD: J4.19, R4.2, U9.3 (PGOOD), U12.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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)
/Power/SW: C42.2, L1.1, Q1.1, Q1.2, Q1.3 (S), Q2.5 (D), U9.8 (SW)
/Power/VIN: J1.1, J7.1, U8.1 (IN+), U8.2 (IN+), U8.3 (IN+), U8.12 (VBUS)
/RST: J3#2.2, U2.11 (B3), U12.39 (GPIO1/TOUCH1/ADC1_CH0)
/RX: J4.11, U2.13 (B1), U12.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
/SCL: J3#2.16, J9.3, U7.8 (SMCLK), U8.9 (SCL), U10.2 (SCL), U12.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF)
/SDA: J3#2.17, J9.4, U7.7 (SMDATA), U8.8 (SDA), U10.1 (SDA), U12.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF)
/TX: J4.10, U2.12 (B2), U12.10 (GPIO17/U1TXD/ADC2_CH6)
/VDD: C7.1, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C46.1, C47.1, J3#2.3, L1.2, R13.1, R14.1, U12.38 (GPIO2/TOUCH2/ADC1_CH1), U14.29 (VDD)
GND: C1.1, C2.1, C4.2, C5.2, C7.2, C9.2, C10.2, C11.2, C13.2, C14.2, C16.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C43.2, C44.2, C46.2, C47.2, C49.2, C51.2, C52.2, H7.1, H8.1, H9.1, H10.1, J1.2, J2.1, J3.5, J3#2.1, J4.1, J4#2.1, J5.4, J8.A1 (GND), J8.A12 (GND), J8.B1 (GND), J8.B12 (GND), J8.S1 (SHIELD), J9.1, Q2.1, Q2.2, Q2.3 (S), Q4.2 (S), R3.1, R5.1, R6.1, R12.2, R15.2, R16.2, SW1.1, SW2.1, TP5.1, U1.2 (GND), U2.5 (A4), U2.7 (GND), U2.10 (B4), U2.15 (GND), U2.16 (GND), U2.17 (GND), U2.18 (GND), U2.19 (GND), U5.2 (GND), U6.2 (GND), U7.5 (GND)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
unnamed: C41.2, R10.1
unnamed: C45.1, R13.2
unnamed: D1.2, J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS)
unnamed: J8.A5 (CC1), R3.2
unnamed: J8.B5 (CC2), R5.2
unnamed: Q1.4 (G), U9.7 (HDRV)
unnamed: Q2.4 (G), R12.1, U9.9 (LDRV)
unnamed: C39.1, Q4.3 (D), U9.2 (EN/SS)
unnamed: C42.1, U9.6 (BOOT)
unnamed: C43.1, U9.10 (BP)
unnamed: C40.1, C41.1, U9.4 (COMP)
unnamed: R16.1, U10.5 (FS0)
unnamed: J4.13, J8.A7 (D-), J8.B7 (D-), U12.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-)
unnamed: J4.14, J8.A6 (D+), J8.B6 (D+), U12.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+)
unnamed: C16.1, U14.16 (VDDIO_08_1)
unnamed: C14.1, U14.15 (VDDIO_18_1)

## Commit log

2024-04-19 Create LICENSE
